File: CE_Arduino_Footprint.kicad_pcb (KiCad board)
At the start: 2 copper layers, 1 part

Commit message: Headers added and labeled
Parts:
- moved Arduino Uno R3 Footprint 18.9 mm to (214.6, 149.9)
